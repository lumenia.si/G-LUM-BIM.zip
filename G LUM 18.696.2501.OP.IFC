Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: GLUM 18W-696.IFC
Time: 2023-10-23T06:39:06
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: GLUM 18W-696
In: Default Storey
SolidWorks Custom Properties - Description: PWR(18W);LUM.FLUX(2501-2770lm)
PSet_Mass_Property - Mass Measure: 4.27123; Area Measure: 0.28585 m2; Volume Measure: 0.00427123 m3
