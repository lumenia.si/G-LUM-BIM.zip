Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: GLUM 53_60W-1593.IFC
Time: 2023-10-23T06:38:05
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: GLUM 53_60W-1593
In: Default Storey
SolidWorks Custom Properties - Description: PWR(53W,60W);LUM.FLUX(7347-9180lm)
PSet_Mass_Property - Mass Measure: 9.678; Area Measure: 0.63476 m2; Volume Measure: 0.009678 m3
