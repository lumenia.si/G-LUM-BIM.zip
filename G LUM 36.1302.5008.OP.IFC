Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: GLUM 36W-1302.IFC
Time: 2023-10-23T06:38:45
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBeam: GLUM 36W-1302
In: Default Storey
SolidWorks Custom Properties - Description: PWR(36W);LUM.FLUX(5008-5548lm)
PSet_Mass_Property - Mass Measure: 7.92396; Area Measure: 0.521568 m2; Volume Measure: 0.00792396 m3
